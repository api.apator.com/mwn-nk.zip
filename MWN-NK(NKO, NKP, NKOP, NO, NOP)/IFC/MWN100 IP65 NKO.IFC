Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: MWN100 IP65 NKO.IFC
Time: 2025-07-09T12:25:46
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBuildingElementProxy: 2000-870000-1/2000-450002-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2000-870000-1/Ko³ek walcowy PN-85021 2,5 x 22-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Dodanie-wyci¹gniêcie6
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Dodanie-wyci¹gniêcie8
In: Default Storey
PredefinedType: ELEMENT
