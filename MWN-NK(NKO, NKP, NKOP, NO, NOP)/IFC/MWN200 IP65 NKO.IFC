Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: MWN200 IP65 NKO.IFC
Time: 2025-07-09T13:12:12
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBuildingElementProxy: 2000-870000-1/Ko³ek walcowy PN-85021 2,5 x 22-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7360-010000-1/Œruba z uchem M10-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7360-010000-1/Œruba z uchem M10-2-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Dodanie-wyci¹gniêcie12
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Dodanie-wyci¹gniêcie7
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Podk³adka PN-82005-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Podk³adka PN-82005-10-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Podk³adka PN-82005-12-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Podk³adka PN-82005-14-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Podk³adka PN-82005-2-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Podk³adka PN-82005-4-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Podk³adka PN-82005-6-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Podk³adka PN-82005-8-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Œruba M-82302-11-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Œruba M-82302-12-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Œruba M-82302-7-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Œruba M-82302-8-solid1
In: Default Storey
PredefinedType: ELEMENT
